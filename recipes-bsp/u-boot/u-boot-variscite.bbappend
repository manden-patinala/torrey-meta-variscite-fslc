SRC_URI += "file://uboot_wls.patch"                   

